#
# Copyright (C) 2017 Wind River Systems, Inc.
#

require recipes-kernel/linux/linux-yocto-measured.inc
require recipes-kernel/linux/linux-yocto-encrypted-storage.inc
require recipes-kernel/linux/linux-yocto-integrity.inc
